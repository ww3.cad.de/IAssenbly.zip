# Autodesk Inventor assembly: zusammenbau
## iProperties
Created: 2007-04
Part Number: zusammenbau
Document SubType Name: Assembly
Designer: Sascha Fleischer
Author: Sascha Fleischer
