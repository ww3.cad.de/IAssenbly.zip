# Autodesk Inventor assembly: Baugruppe1-02
## iProperties
Created: 2007-04
Part Number: Baugruppe1-02
Document SubType Name: Assembly
Designer: Sascha Fleischer
Author: Sascha Fleischer
