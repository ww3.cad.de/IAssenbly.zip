# Autodesk Inventor assembly: Baugruppe1-01
## iProperties
Created: 2007-04
Part Number: Baugruppe1-01
Document SubType Name: Assembly
Designer: Sascha Fleischer
Author: Sascha Fleischer
